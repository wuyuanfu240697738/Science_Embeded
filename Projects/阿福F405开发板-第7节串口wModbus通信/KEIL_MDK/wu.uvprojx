# Keil uVision project wu.uvprojx, settings and files
target STM32F4 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wu +hex
  AfterMake: fromelf.exe --bin -o ./@p.bin ./output/@p.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c include: ..\Main;..\..\..\My_Drivers\Src;..\..\..\My_Drivers\Drive;..\..\..\Mid_Drivers\Micrium\Software\uCOS-III\Source;..\..\..\Mid_Drivers\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\..\..\Mid_Drivers\Micrium\Software\uCOS-Hook;..\..\..\Mid_Drivers\Micrium\Software\uC-CPU;..\..\..\Mid_Drivers\Micrium\Software\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\..\..\ST_Drivers\ST32F4xx_HAL_Driver\Inc\Legacy;..\..\..\ST_Drivers\ST32F4xx_HAL_Driver\Inc;..\..\..\ST_Drivers\ST32F4xx_HAL_CMSIS\Include;..\..\..\ST_Drivers\ST32F4xx_HAL_CMSIS\Device\ST\STM32F4xx\Include;..\..\..\My_Drivers\wMB\mb
  asm include: ..\..\..\Mid_Drivers\Micrium\Software\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\..\..\Mid_Drivers\Micrium\Software\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\ARM
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User/APP
    ../Main/: main.c Cpucfg.h os_cfg.h os_cfg_app.h
  group User/Driver
    ../../../My_Drivers/Drive/: wLed.c wSerial.c
  group User/Src
    ../../../My_Drivers/Src/: wGpio.c wIt.c wSys.c wUart.c wDma.c wSprintf.c wStr.c
  group uC/Hook
    ../../../Mid_Drivers/Micrium/Software/uCOS-Hook/: os_app_hooks.c os_bsp.c
  group uC/CPU
    ../../../Mid_Drivers/Micrium/Software/uC-CPU/: cpu_core.c
    ../../../Mid_Drivers/Micrium/Software/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../../../Mid_Drivers/Micrium/Software/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
  group uC/Source
    ../../../Mid_Drivers/Micrium/Software/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/Port
    ../../../Mid_Drivers/Micrium/Software/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../../../Mid_Drivers/Micrium/Software/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm
  group HALF4_CMSIS
    ../../../ST_Drivers/ST32F4xx_HAL_CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../../ST_Drivers/ST32F4xx_HAL_CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f405xx.s
  group HALF4_Drive
    ../../../ST_Drivers/ST32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_uart.c
  group wModbus
    ../../../My_Drivers/wMB/mb/: mb.c mbevent.c smb.c smbbuf.c
software components: CMSIS:CORE 5.2.0
